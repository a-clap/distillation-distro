SUMMARY = "Image Sato for BananaPI BPI-M2 Zero"

include image.bb

IMAGE_FEATURES += "splash"
IMAGE_INSTALL += "go-gui"
