pkg_postinst:${PN}-hwdb:bananapi-zero() {
}

pkg_prerm:udev-hwdb:bananapi-zero() {

}