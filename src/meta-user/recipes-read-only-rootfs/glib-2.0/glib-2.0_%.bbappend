gio_module_cache_common:bananapi-zero() {
}