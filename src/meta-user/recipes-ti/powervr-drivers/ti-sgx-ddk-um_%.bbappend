TARGET_PRODUCT:${MACHINE} = "ti335x"
COMPATIBLE_MACHINE:${MACHINE} = "${MACHINE}"


